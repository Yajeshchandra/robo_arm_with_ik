Commit message: jacobian_teleop_2.py

File: src/arm_urdf/urdf/arm_urdf.urdf (robot description, URDF)
Before this commit: robot arm_urdf, 7 links, 6 joints
Joints:
- joint base_joint: origin xyz=0.0 0.0 0.17 rpy=0 0 0 -> xyz=0.0 0.0 1.17 rpy=0 0 0
